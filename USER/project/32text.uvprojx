# Keil uVision project 32text.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 32text +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\FWLIB\inc;..\HARDWARE\myoled;..\..\CORE;..\..\USER;..\..\SYSTEM\Systick;..\..\HARDWARE\LED;..\..\HARDWARE\IIC;..\..\HARDWARE\myoled;..\..\HARDWARE\KEY;..\..\HARDWARE\Bee;..\..\HARDWARE\DHT11;..\..\HARDWARE\FAN;..\..\HARDWARE\ADC;..\..\FreeRtos\include;..\..\FreeRtos\port\ARM_CM4F;..\..\FreeRtos\port\MemMang;..\..\FreeRtos;..\..\HARDWARE\timer;..\..\HARDWARE\pwn;..\..\HARDWARE\USART1
  asm include: ..\..\CORE;..\..\FWLIB\inc;..\..\SYSTEM\Systick;..\..\USER;..\..\FWLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group USER
    ../: system_stm32f4xx.c stm32f4xx_it.c
    ./: main.c
  group SYSTEM
    ../../SYSTEM/Systick/: Systick.c
  group HARDWARD
    ../../HARDWARE/ADC/: adc.c
    ../../HARDWARE/Bee/: bee.c
    ../../HARDWARE/DHT11/: dht11.c
    ../../HARDWARE/FAN/: fan.c
    ../../HARDWARE/IIC/: softwareiic.c
    ../../HARDWARE/KEY/: KEY.c
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/myoled/: myoled.c
    ../../HARDWARE/oled_show/: oled_show.c
    ../../HARDWARE/USART1/: usart1.c usart2_wife.c
    ../../HARDWARE/timer/: timer.c
    ../../HARDWARE/pwn/: pwn2.c pwn1.C
